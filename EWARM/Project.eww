<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SweepRobot_Testing_Host_STM32F4.ewp</path>
  </project>
  <batchBuild />
</workspace>
